# Keil uVision project VoltageCurrent.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: VoltageCurrent +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\includes
  asm include: .\includes;.\sources
  group StartUp
    ./: STARTUP.A51
  group Sources
    ./sources/: CPU_Init.c KeyBoard.c main.c TM1629A.c Display.c RN8209D.c UartDeal.c
  group Inculdes
    ./includes/: CPU_Init.h DataManage.h KeyBoard.h Mytype.h STC15F2K48AS.h WordCode.h TM1629A.h Display.h UartDeal.h DataChange.h
